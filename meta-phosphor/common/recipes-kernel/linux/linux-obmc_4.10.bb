KBRANCH ?= "dev-4.10"
LINUX_VERSION ?= "4.10.17"

SRCREV="30570bc46bccc1434efefbb8a69b34b222047839"

require linux-obmc.inc
