SRCREV ?= "bcb4f80f497511e79cd06dde6ac91b369966e561"
SKELETON_URI ?= "git://github.com/garden-liang/skeleton"
