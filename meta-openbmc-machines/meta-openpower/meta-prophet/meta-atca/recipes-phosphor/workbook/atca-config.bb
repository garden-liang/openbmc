SUMMARY = "Atca board wiring"
DESCRIPTION = "Board wiring information for the Atca system."
PR = "r1"

inherit config-in-skeleton
