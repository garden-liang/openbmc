FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://atca.xml.patch.xml"
